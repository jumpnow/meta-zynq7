UBOOT_VERSION = "v2019.02"

SRCREV = "f6b4a4548dbc358ce801b860df08440de79aa7c5"
