UBOOT_VERSION = "v2022.01"

UBRANCH = "xlnx_rebase_v2022.01"

SRCREV = "776ce68e76ae600e26396d356c48b26596be4e48"

UBOOT_SUFFIX = "img"
